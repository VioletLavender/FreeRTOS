# IAR project I2C_EEPROM_Master_DMA_Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F032R8T6 MindMotion MM32F032R8T6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\..\..\3_Device\CMSIS\IAR_CORE; ..\..\..\..\3_Device\MM32F032xx_s\HAL_lib\inc; ..\..\..\..\3_Device\MM32F032xx_s\Include; ..\Peripheral\inc; ..\BSP\inc; ..\APP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_EEPROM_Master_DMA_Interrupt.bin
  ILINK.IlinkOutputFile: I2C_EEPROM_Master_DMA_Interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: bsp_eeprom.c bsp_led.c
  group HAL_LIB
    ../../../../3_Device/MM32F032xx_s/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_crc.c HAL_dbg.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_ver.c HAL_wwdg.c
  group Peripheral
    ../Peripheral/: i2c.c systick.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../3_Device/MM32F032xx_s/Source/IAR_StartAsm/: startup_MM32F032xx_s_IAR.s
    ../../../../3_Device/MM32F032xx_s/Source/: system_MM32F032xx_s.c
