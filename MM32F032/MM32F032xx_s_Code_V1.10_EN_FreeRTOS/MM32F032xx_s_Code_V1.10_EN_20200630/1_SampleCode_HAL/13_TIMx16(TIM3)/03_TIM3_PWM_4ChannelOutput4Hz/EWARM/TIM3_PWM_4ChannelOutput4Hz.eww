<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM3_PWM_4ChannelOutput4Hz.ewp</path>
    </project>
    <batchBuild />
</workspace>
