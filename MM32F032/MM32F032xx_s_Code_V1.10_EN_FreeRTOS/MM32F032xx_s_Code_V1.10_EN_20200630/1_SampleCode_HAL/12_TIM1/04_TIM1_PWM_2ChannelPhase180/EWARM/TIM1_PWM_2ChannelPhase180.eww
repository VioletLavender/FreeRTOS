<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM1_PWM_2ChannelPhase180.ewp</path>
    </project>
    <batchBuild />
</workspace>
