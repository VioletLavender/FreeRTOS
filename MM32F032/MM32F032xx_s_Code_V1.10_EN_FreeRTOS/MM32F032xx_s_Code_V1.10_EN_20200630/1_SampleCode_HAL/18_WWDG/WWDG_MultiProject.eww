<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01_WWDG_Reset\EWARM\WWDG_Reset.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\02_WWDG_Reset_Interrupt\EWARM\WWDG_Reset_Interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
