<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_TIM1_Trigger_DMA_AnyChannel.ewp</path>
    </project>
    <batchBuild />
</workspace>
