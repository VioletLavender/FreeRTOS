<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BKP_BakupData.ewp</path>
    </project>
    <batchBuild />
</workspace>
