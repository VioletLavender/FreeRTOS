<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01_IWDG_Reset\EWARM\IWDG_Reset.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\02_IWDG_WakeUpFromStandbyMode\EWARM\IWDG_WakeUpFromStandbyMode.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03_IWDG_WakeUpFromStopMode\EWARM\IWDG_WakeUpFromStopMode.ewp</path>
    </project>
    <batchBuild />
</workspace>
