<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM1_TIM2_MasterSlaveMode.ewp</path>
    </project>
    <batchBuild />
</workspace>
